# Keil uVision project FW.uvprojx, settings and files
target FW3-F100CB (ARM-ADS)
  device: STM32F100CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(24000000) ELITTLE
  output: FW3-F100CB
  c flags: Optim=1 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_MD_VL STM32F100CB VECT_TAB_OFFSET=0x1000 UTRACKER_4
  c include: src;src\FreeRTOS.8.0.1;src\FreeRTOS.8.0.1\include;src\FreeRTOS.8.0.1\portable\MemMang;src\FreeRTOS.8.0.1\portable\RVDS\ARM_CM3;src\nmealib\include;Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    src/: main.c hardware.c gps.c gsm.c acc.c debug.c can.c kalman.c matrix.c utility.c command.c gpsOne.c fw_update.c ring_buffer.c startup_stm32f.s printf2.c
  group FreeRTOS.8.0.1
    src/FreeRTOS.8.0.1/portable/MemMang/: heap_2.c
    src/FreeRTOS.8.0.1/: list.c queue.c tasks.c
    src/FreeRTOS.8.0.1/portable/RVDS/ARM_CM3/: port.c
  group NMEA
    src/nmealib/src/: tok.c gmath.c info.c parse.c sentence.c time.c
  group StdPeriph_F10X
    src/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c misc.c stm32f10x_adc.c stm32f10x_dma.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c stm32f10x_dbgmcu.c
target FW3-F101RC (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FW3-F101RC
  c flags: Optim=2 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_HD STM32F101RC VECT_TAB_OFFSET=0x1000 UTRACKER_3
  c include: src;Libraries\STM32F10x_StdPeriph_Driver\inc;src\FreeRTOS.8.0.1;src\FreeRTOS.8.0.1\include;src\FreeRTOS.8.0.1\portable\MemMang;src\FreeRTOS.8.0.1\portable\RVDS\ARM_CM3;src\nmealib\include
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x1e000
  memory RVCT9: RAM 0x20000000 size 0x8000
