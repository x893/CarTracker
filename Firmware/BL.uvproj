# Keil uVision project BL.uvproj, settings and files
target BL-F100CB (ARM-ADS)
  device: STM32F100CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BL3-F100CB
  c flags: Optim=2 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_MD_VL STM32F100CB VECT_TAB_OFFSET=0 BL_VERSION UTRACKER_4
  c misc: --c99
  c include: src;src\FreeRTOS.8.0.1;src\FreeRTOS.8.0.1\include;src\FreeRTOS.8.0.1\portable\MemMang;src\FreeRTOS.8.0.1\portable\RVDS\ARM_CM3;src\nmealib\include;Libraries\STM32F10x_StdPeriph_Driver\inc
  asm define: BL_VERSION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group App
    src/: main.c hardware.c debug.c utility.c fw_update.c startup_stm32f.s
  group StdPeriph_F10X
    src/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_wwdg.c stm32f10x_dbgmcu.c
target BL-F101RC (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: BL3-F101RC
  c flags: Optim=2 OneElfS=1
  c define: NDEBUG USE_STDPERIPH_DRIVER STM32F10X_HD STM32F101RC VECT_TAB_OFFSET=0 BL_VERSION UTRACKER_3
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x8000
